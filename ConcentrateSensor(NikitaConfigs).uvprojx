# Keil uVision project ConcentrateSensor(NikitaConfigs).uvprojx, settings and files
target TriglaTouchScreen (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: TriglaTouchScreen +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Files
    ./: global_var.c GUILogic.c KeyBoard.c main.c Net_User.c qspi.c serverPart.c settings.c timer6.c timer7.c Verdana20.c Verdana40.c Verdana220.c modbus.c
  group Headers
    ./: global_var.h GUILogic.h KeyBoard.h KeyBoardWindowDLG.h main.h Net_User.h qspi.h serverPart.h settings.h timer6.h timer7.h modbus.h
  group Windows
    ./: StartWindow_DLG.c MenuWindowDLG.c PanelNetConfigsWindowDLG.c SensorNetConfigsWindowDLG.c PIDConfigsWindowDLG.c ParamsConfigsWindowDLG.c KeyBoardWindowDLG.c ModBusWindowDLG.c
software components: CMSIS:CORE 5.1.2, CMSIS:RTOS:Keil RTX 4.81.1, Network:CORE 6.6.0, Network:Interface:ETH 6.6.0, Network:Socket:TCP 6.6.0, Board Support:Drivers:Basic I/O 1.1.1, Board Support:Drivers:QSPI 1.1.1, Board Support:Drivers:SDRAM 1.1.1, Board Support:Drivers:Touch Screen 1.1.1, Board Support:Touchscreen 1.1.1, Board Support:emWin LCD 1.1.1, CMSIS Driver:Ethernet MAC 1.6.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.2.0, Device:STM32Cube Framework:Classic 1.2.6, Device:STM32Cube HAL:Common 1.2.6, Device:STM32Cube HAL:Cortex 1.2.6, Device:STM32Cube HAL:DMA 1.2.6, Device:STM32Cube HAL:DMA2D 1.2.6, Device:STM32Cube HAL:Flash 1.2.6, Device:STM32Cube HAL:GPIO 1.2.6, Device:STM32Cube HAL:I2C 1.2.6, Device:STM32Cube HAL:LTDC 1.2.6, Device:STM32Cube HAL:NOR 1.2.6, Device:STM32Cube HAL:PWR 1.2.6, Device:STM32Cube HAL:QSPI 1.2.6, Device:STM32Cube HAL:RCC 1.2.6, Device:STM32Cube HAL:SDRAM 1.2.6, Device:STM32Cube HAL:UART 1.2.6, Device:Startup 1.2.2, Graphics Display:STM32F746G-Discovery 1.0.2, Graphics:CORE 5.30.0, Graphics:Input Device:Touchscreen 5.30.0, Graphics:Tools:GUI Builder 5.30.0
